# Keil uVision project LED_CONTROL.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_CONTROL
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group SEVICE
    ./SERVICE/: Bit_Math.h Mc_Hw.h Types.h
  group NVIC
    ./MCAL/NVIC/: NVIC.c NVIC_Cfg.c NVIC.h NVIC_Cfg.h
  group SYSTICK
    ./MCAL/SYSTICK/: Systick.c Systick.h
  group PORT
    ./MCAL/PORT/: PORT.c PORT_Config.c PORT.h
  group DIO
    ./MCAL/DIO/: DIO.c DIO.h
  group APP
    ./APP/: App.c App.h
  group MAIN
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
